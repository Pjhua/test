# Keil uVision project 智慧生活.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 智慧生活
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --locale=english --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546 --diag_suppress=1295
  c include: .\user;.\strat\cmsis;.\strat\fwlib\inc;.\HARDWARE\inc;.\HARDWARE\mpu6050;.\HARDWARE\mpu6050\eMPL;.\app;.\fatfs\source;.\HARDWARE\audio;.\HARDWARE\malloc;.\LVGL\lvgl_src;.\LVGL\lvgl_src\src;.\LVGL\porting;.\LVGL\lvgl_app;.\LVGL\lvgl_app\custom;.\LVGL\lvgl_app\generated;.\LVGL\lvgl_app\generated\guider_customer_fonts;.\freeRTOS\Source\include;.\freeRTOS\Source\portable\RVDS\ARM_CM4F;.\freeRTOS\Source\user
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./strat/cmsis/: system_stm32f4xx.c startup_stm32f40_41xxx.s io_bit.h
  group fwlib
    ./strat/fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ./user/: main.c
  group HARDWARE
    ./HARDWARE/src/: delay.c beep.c key.c led.c fan.c relay.c multi_button.c usart1.c usart2.c usart3.c esp8266.c cJSON.c exti.c timer.c lcd_init.c lcd.c spi.c w25qxx.c gbk_utf8_unicode.c sht3x.c iic.c mlx9061x.c CST816S.c CTIIC.c dma.c adc.c iwdg.c wwdg.c rtc.c pwm.c capture.c remote.c w2812.c sd_driver.c bmp.c scanf_dir.c
    ./HARDWARE/mpu6050/: mpu6050.c
    ./HARDWARE/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group fatfs
    ./fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group music
    ./HARDWARE/audio/: audioplay.c exfuns.c i2s.c wavplay.c wm8978.c wmiic.c lyric.c
  group malloc
    ./HARDWARE/malloc/: malloc.c
  group app
    ./app/: app.c app_gui.c clock.c ebook.c
  group lvgl_core
    ./LVGL/lvgl_src/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgl_display
    ./LVGL/lvgl_src/src/display/: lv_display.c
  group lvgl_draw
    ./LVGL/lvgl_src/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./LVGL/lvgl_src/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ./LVGL/lvgl_src/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ./LVGL/lvgl_src/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group lvgl_font
    ./LVGL/lvgl_src/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_indev
    ./LVGL/lvgl_src/src/indev/: lv_indev.c lv_indev_scroll.c
  group lvgl_layouts
    ./LVGL/lvgl_src/src/layouts/: lv_layout.c
    ./LVGL/lvgl_src/src/layouts/grid/: lv_grid.c
    ./LVGL/lvgl_src/src/layouts/flex/: lv_flex.c
  group lvgl_libs
    ./LVGL/lvgl_src/src/libs/barcode/: code128.c lv_barcode.c
    ./LVGL/lvgl_src/src/libs/bin_decoder/: lv_bin_decoder.c
    ./LVGL/lvgl_src/src/libs/bmp/: lv_bmp.c
    ./LVGL/lvgl_src/src/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/lvgl_src/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ./LVGL/lvgl_src/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_cbfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/lvgl_src/src/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/lvgl_src/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ./LVGL/lvgl_src/src/libs/libpng/: lv_libpng.c
    ./LVGL/lvgl_src/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ./LVGL/lvgl_src/src/libs/lz4/: lz4.c
    ./LVGL/lvgl_src/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/lvgl_src/src/libs/rle/: lv_rle.c
    ./LVGL/lvgl_src/src/libs/rlottie/: lv_rlottie.c
    ./LVGL/lvgl_src/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./LVGL/lvgl_src/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group lvgl_misc
    ./LVGL/lvgl_src/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ./LVGL/lvgl_src/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group lvgl_osal
    ./LVGL/lvgl_src/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group lvgl_others
    ./LVGL/lvgl_src/src/others/file_explorer/: lv_file_explorer.c
    ./LVGL/lvgl_src/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./LVGL/lvgl_src/src/others/gridnav/: lv_gridnav.c
    ./LVGL/lvgl_src/src/others/ime/: lv_ime_pinyin.c
    ./LVGL/lvgl_src/src/others/imgfont/: lv_imgfont.c
    ./LVGL/lvgl_src/src/others/monkey/: lv_monkey.c
    ./LVGL/lvgl_src/src/others/observer/: lv_observer.c
    ./LVGL/lvgl_src/src/others/snapshot/: lv_snapshot.c
    ./LVGL/lvgl_src/src/others/sysmon/: lv_sysmon.c
    ./LVGL/lvgl_src/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group lvgl_stdlib
    ./LVGL/lvgl_src/src/stdlib/: lv_mem.c
    ./LVGL/lvgl_src/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./LVGL/lvgl_src/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./LVGL/lvgl_src/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./LVGL/lvgl_src/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgl_themes
    ./LVGL/lvgl_src/src/themes/: lv_theme.c
    ./LVGL/lvgl_src/src/themes/simple/: lv_theme_simple.c
    ./LVGL/lvgl_src/src/themes/mono/: lv_theme_mono.c
    ./LVGL/lvgl_src/src/themes/default/: lv_theme_default.c
  group lvgl_tick
    ./LVGL/lvgl_src/src/tick/: lv_tick.c
  group lvgl_widgets
    ./LVGL/lvgl_src/src/widgets/animimage/: lv_animimage.c
    ./LVGL/lvgl_src/src/widgets/arc/: lv_arc.c
    ./LVGL/lvgl_src/src/widgets/bar/: lv_bar.c
    ./LVGL/lvgl_src/src/widgets/button/: lv_button.c
    ./LVGL/lvgl_src/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ./LVGL/lvgl_src/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/lvgl_src/src/widgets/canvas/: lv_canvas.c
    ./LVGL/lvgl_src/src/widgets/chart/: lv_chart.c
    ./LVGL/lvgl_src/src/widgets/checkbox/: lv_checkbox.c
    ./LVGL/lvgl_src/src/widgets/dropdown/: lv_dropdown.c
    ./LVGL/lvgl_src/src/widgets/image/: lv_image.c
    ./LVGL/lvgl_src/src/widgets/imagebutton/: lv_imagebutton.c
    ./LVGL/lvgl_src/src/widgets/keyboard/: lv_keyboard.c
    ./LVGL/lvgl_src/src/widgets/label/: lv_label.c
    ./LVGL/lvgl_src/src/widgets/led/: lv_led.c
    ./LVGL/lvgl_src/src/widgets/line/: lv_line.c
    ./LVGL/lvgl_src/src/widgets/list/: lv_list.c
    ./LVGL/lvgl_src/src/widgets/lottie/: lv_lottie.c
    ./LVGL/lvgl_src/src/widgets/menu/: lv_menu.c
    ./LVGL/lvgl_src/src/widgets/msgbox/: lv_msgbox.c
    ./LVGL/lvgl_src/src/widgets/objx_templ/: lv_objx_templ.c
    ./LVGL/lvgl_src/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ./LVGL/lvgl_src/src/widgets/roller/: lv_roller.c
    ./LVGL/lvgl_src/src/widgets/scale/: lv_scale.c
    ./LVGL/lvgl_src/src/widgets/slider/: lv_slider.c
    ./LVGL/lvgl_src/src/widgets/span/: lv_span.c
    ./LVGL/lvgl_src/src/widgets/spinbox/: lv_spinbox.c
    ./LVGL/lvgl_src/src/widgets/spinner/: lv_spinner.c
    ./LVGL/lvgl_src/src/widgets/switch/: lv_switch.c
    ./LVGL/lvgl_src/src/widgets/table/: lv_table.c
    ./LVGL/lvgl_src/src/widgets/tabview/: lv_tabview.c
    ./LVGL/lvgl_src/src/widgets/textarea/: lv_textarea.c
    ./LVGL/lvgl_src/src/widgets/tileview/: lv_tileview.c
    ./LVGL/lvgl_src/src/widgets/win/: lv_win.c
  group lvgl_init
    ./LVGL/lvgl_src/src/: lv_init.c
  group lvgl_porting
    ./LVGL/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl_custom
    ./LVGL/lvgl_app/custom/: custom.c myFont_simkai16.c ebook_view.c music_player.c bin_image.c lv_merge_decoder.c
  group lvgl_generated
    ./LVGL/lvgl_app/generated/: events_init.c gui_guider.c setup_scr_screen_app.c setup_scr_screen_cal.c setup_scr_screen_clk.c setup_scr_screen_ebook.c setup_scr_screen_look.c setup_scr_screen_main_1.c setup_scr_screen_main_2.c setup_scr_screen_music.c setup_scr_screen_pic.c widgets_init.c
    ./LVGL/lvgl_app/generated/guider_fonts/: lv_font_montserratMedium_14.c lv_font_montserratMedium_12.c
    ./LVGL/lvgl_app/generated/images/: _app_70_RGB565A8_70x70.c _back_240280_RGB565A8_240x280.c _calc_70_RGB565A8_70x70.c _clock_70_RGB565A8_70x70.c _ebook_70_RGB565A8_70x70.c _look_RGB565A8_70x70.c _music_70_RGB565A8_70x70.c _notepad_70_RGB565A8_70x70.c _paint_70_RGB565A8_70x70.c _picture_70_RGB565A8_70x70.c _set_70_RGB565A8_70x70.c _sms_70_RGB565A8_70x70.c _PauseP_RGB565A8_80x40.c _PlayP_RGB565A8_80x40.c _NextP_RGB565A8_60x40.c _PrevP_RGB565A8_60x40.c mergeBinFile.c
  group freeRTOS
    ./freeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freeRTOS/Source/portable/MemMang/: heap_4.c
    ./freeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group freeRTOS_app
    ./freeRTOS/Source/user/: freertos_app.c
